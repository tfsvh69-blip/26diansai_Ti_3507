# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6100001::V6.10.1::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..;..\app;..\app\tasks;..\bsp;..\bsp\board;..\bsp\delay;..\common;..\module;..\module\oled;..\module\imu;..\module\laser;..\module\vision;..\module\nrf24l01;..\algo;..\third_party\FreeRTOS\include;..\third_party\FreeRTOS\portable\ARM_CM0;..\third_party\ti_driverlib;..\third_party\st_lsm6dsv16x
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group bsp_delay
    ../bsp/delay/: Delay.c Delay.h
  group third_party_ti_driverlib
    ../third_party/ti_driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
  group app
    ../app/: app_main.c app_main.h app_led_task.c app_led_task.h app_imu_uart_task.c app_imu_uart_task.h app_uart_test_task.c app_uart_test_task.h app_motor_test_task.c app_motor_test_task.h app_relay_test_task.c app_relay_test_task.h app_periph_test_task.c app_periph_test_task.h app_servo_test_task.c app_servo_test_task.h app_ui_task.c app_ui_task.h app_robot_core.c app_robot_core.h app_nrf24_tx_test_task.c app_nrf24_tx_test_task.h
  group app_tasks
    ../app/tasks/: app_tasks.h task1.c task2.c task3.c task4.c task5.c task6.c
  group bsp
    ../bsp/: bsp_board.c bsp_board.h bsp_led.c bsp_led.h bsp_imu_port.c bsp_imu_port.h bsp_uart.c bsp_uart.h bsp_motor.c bsp_motor.h bsp_key.c bsp_line.c bsp_relay.c bsp_buzzer.c bsp_buzzer.h bsp_servo.c bsp_servo.h bsp_nrf24_port.c bsp_nrf24_port.h
  group common
    ../common/: app_config.h message_def.h FreeRTOSConfig.h
  group bsp_board
    ../app/: main.c
    ./: startup_mspm0g350x_uvision.s
    ../bsp/board/: ti_msp_dl_config.h ti_msp_dl_config.c
  group module_imu
    ../module/imu/: atk_ms6dsv.c atk_ms6dsv.h
  group module_oled
    ../module/oled/: OLED.c OLED.h OLED_Data.c OLED_Data.h
  group module_laser
    ../module/laser/: laser_ld14.c laser_ld14.h
  group module_vision
    ../module/vision/: ball_parser.c ball_parser.h
  group module_nrf24l01
    ../module/nrf24l01/: nrf24l01.c nrf24l01.h
  group third_party_st_lsm6dsv16x
    ../third_party/st_lsm6dsv16x/: lsm6dsv16x_reg.c lsm6dsv16x_reg.h
  group third_party_FreeRTOS
    ../third_party/FreeRTOS/portable/: heap_4.c
    ../third_party/FreeRTOS/portable/ARM_CM0/: port.c portasm.c portasm.h portmacro.h
    ../third_party/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
